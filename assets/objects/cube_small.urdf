Commit message: update zonopy test

File: assets/objects/cube_small.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=1 1 1; visual mesh filename=cube.obj scale=1 1 1
